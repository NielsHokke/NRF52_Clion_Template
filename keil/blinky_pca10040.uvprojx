# Keil uVision project blinky_pca10040.uvprojx, settings and files
target nrf52832_xxaa (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.16.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BOARD_PCA10040 BSP_DEFINES_ONLY CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\..\..\config;..\..\..\SDK\components;..\..\..\SDK\components\boards;..\..\..\SDK\components\drivers_nrf\nrf_soc_nosd;..\..\..\SDK\components\libraries\balloc;..\..\..\SDK\components\libraries\bsp;..\..\..\SDK\components\libraries\delay;..\..\..\SDK\components\libraries\experimental_log;..\..\..\SDK\components\libraries\experimental_log\src;..\..\..\SDK\components\libraries\experimental_memobj;..\..\..\SDK\components\libraries\experimental_section_vars;..\..\..\SDK\components\libraries\strerror;..\..\..\SDK\components\libraries\util;..;..\..\..\SDK\integration\nrfx;..\..\..\SDK\modules\nrfx;..\..\..\SDK\modules\nrfx\hal;..\..\..\SDK\modules\nrfx\mdk;..\config
  asm define: as above
  asm misc: --cpreproc_opts=-DBOARD_PCA10040,-DBSP_DEFINES_ONLY,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: ..\config;..\..\..\SDK\components;..\..\..\..\..\SDK\components\boards;..\..\..\..\..\SDK\components\drivers_nrf\nrf_soc_nosd;..\..\..\SDK\components\libraries\balloc;..\..\..\SDK\components\libraries\bsp;..\..\..\SDK\components\libraries\delay;..\..\..\SDK\components\libraries\experimental_log;..\..\..\SDK\components\libraries\experimental_log\src;..\..\..\SDK\components\libraries\experimental_memobj;..\..\..\SDK\components\libraries\experimental_section_vars;..\..\..\SDK\components\libraries\strerror;..\..\..\SDK\components\libraries\util;..;..\..\..\SDK\integration\nrfx;..\..\..\SDK\modules\nrfx;..\..\..\SDK\modules\nrfx\hal;..\..\..\SDK\modules\nrfx\mdk;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress 6330
  group Application
    ../src/: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../SDK/components/boards/: boards.c
  group nRF_Libraries
    ../../../SDK/components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../SDK/components/libraries/strerror/: nrf_strerror.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.16.0
